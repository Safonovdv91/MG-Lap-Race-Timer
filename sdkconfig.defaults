## sdkconfig.defaults
```kconfig
CONFIG_LWIP_TCP_MAXRTX=4
CONFIG_LWIP_TCP_SYNMAXRTX=3
CONFIG_LWIP_MAX_ACTIVE_TCP=8
```
